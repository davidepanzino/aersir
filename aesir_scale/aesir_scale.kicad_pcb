# Repository davidepanzino/aersir

## KiCad design aesir_scale/aesir_scale.kicad_pcb

Board: 2 copper layers, 60.0 x 50.0 mm, 52 parts (0 on the bottom side), 39 nets.

Parts:
C1, C2: 14p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C5, C6, C7, C13, C16: 100n; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C4: 1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C8, C10, C11: 4u7; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C14: 10u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C15: 22u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1, D2: pwr; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
D3: MBR1020VL; D_SOD-323_HandSoldering
D4: NUP2105L; SOT-23
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_ISO7380_Pad
J1, J3: jst xh 4; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J2, J5: jst gh; JST_GH_SM04B-GHS-TB_1x04-1MP_P1.25mm_Horizontal
J4: jst_sh 6; JST_SH_SM06B-SRSS-TB_1x06-1MP_P1.00mm_Horizontal
J6: USB_C_Receptacle_USB2.0; USB_C_Receptacle_Palconn_UTC16-G
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R1, R6: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2, R3, R4, R5: 51; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7, R8: 4k7; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9, R10: 470; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R11: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R12, R13: 5k1; R_0603_1608Metric
R14, R15, R16, R17: 1M; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U1: STM32U575CGTx; LQFP-48_7x7mm_P0.5mm
U2: NAU7802SGI; SOI16_NAU7802SGI_NUV
U3: AZ1117CH2-3.3TRG1; SOT-223-3_TabPin2
U4: TJA1051T; SOIC-8_3.9x4.9mm_P1.27mm
U5: USBLC6-2SC6; SOT-23-6
Y1: 48MHz; Crystal_SMD_0603-2Pin_6.0x3.5mm_HandSoldering

Connections:
+3V3: C3.1, C4.1, C8.1, C11.1, C13.1, C15.2, C16.1, J1.4, J3.4, J4.1, R1.1, R7.1, R8.1, R9.1, U1.1 (VBAT), U1.9 (VDDA), U1.24 (VDD), U1.36 (VDD), U1.48 (VDD), U2.1 (REFP), U2.15 (DVDD), U2.16 (AVDD/LDO), U3.3 (VO), U4.3 (VCC)
/BOOT0: J4.5, R6.1, U1.44 (PH3)
/CAN_H: D4.1 (K), J2.2, J5.2, JP1.1 (A), U4.7 (CANH)
/CAN_L: D4.2 (K), J2.3, J5.3, R11.2, U4.6 (CANL)
/CAN_RX: U1.45 (PB8), U4.4 (RXD)
/CAN_TX: U1.46 (PB9), U4.1 (TXD)
/DRDY: U1.29 (PA8), U2.12 (DRDY)
/IO_LED: R10.1, U1.30 (PA9)
/LOAD1_N: J3.1, R5.1
/LOAD1_P: J3.2, R4.1
/LOAD2_N: J1.1, R2.2
/LOAD2_P: J1.2, R3.2
/NRST: J4.6, R1.2, U1.7 (NRST)
/OSC_IN: C1.1, U1.5 (PH0), Y1.1
/OSC_OUT: C2.1, U1.6 (PH1), Y1.2
/SCL: R8.2, U1.27 (PB14), U2.13 (SCLK)
/SDA: R7.2, U1.28 (PB15), U2.14 (SDIO)
/SW_CLK: J4.3, U1.37 (PA14)
/SW_DIO: J4.4, U1.34 (PA13)
/USB_D_N: J6.A7 (D-), J6.B7 (D-), U1.32 (PA11), U5.1 (I/O1), U5.6 (I/O1)
/USB_D_P: J6.A6 (D+), J6.B6 (D+), U1.33 (PA12), U5.3 (I/O2), U5.4 (I/O2)
Earth: C1.2, C2.2, C3.2, C4.2, C5.2, C8.2, C10.1, C11.2, C13.2, C14.1, C15.1, C16.2, D1.1 (K), D2.1 (K), D4.3 (A), J1.3, J2.4, J2.MP (MountPin), J3.3, J4.2, J4.MP (MountPin), J5.4, J5.MP (MountPin), J6.A1 (GND), J6.A12 (GND), J6.B1 (GND), J6.B12 (GND), J6.S1 (SHIELD), R6.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, U1.8 (VSSA), U1.23 (VSS), U1.35 (VSS), U1.47 (VSS), U2.7 (REFN), U2.8 (AVSS), U2.9 (DVSS), U3.2 (GND), U4.2 (GND), U4.8 (S), U5.2 (GND)
unnamed: D1.2 (A), R9.2
unnamed: D2.2 (A), R10.2
unnamed: D3.2 (A), J6.A4 (VBUS), J6.A9 (VBUS), J6.B4 (VBUS), J6.B9 (VBUS)
unnamed: H1.1, R14.1
unnamed: H2.1, R15.1
unnamed: H3.1, R16.1
unnamed: H4.1, R17.1
unnamed: J6.A5 (CC1), R12.1
unnamed: J6.B5 (CC2), R13.1
unnamed: JP1.2 (B), R11.1
unnamed: C10.2, U1.22 (VCAP)
unnamed: C5.1, U2.6 (VBG)
unnamed: C6.1, R5.2, U2.2 (VIN1N)
unnamed: C6.2, R4.2, U2.3 (VIN1P)
unnamed: C7.1, R2.1, U2.4 (VIN2N)
unnamed: C7.2, R3.1, U2.5 (VIN2P)
VCC: C14.2, D3.1 (K), J2.1, J5.1, U3.1 (VI), U5.5 (VBUS)

## Commit log

2024-02-06 upload
